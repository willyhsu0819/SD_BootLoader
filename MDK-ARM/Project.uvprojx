# Keil uVision project Project.uvprojx, settings and files
target STM32F429ZI_NUCLEO_144 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429ZI_NUCLEO_144
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144;..\..\..\..\..\..\Middlewares\Third_Party\FatFs_f4\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c bsp_driver_sd.c fatfs.c sd_diskio.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs_f4/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs_f4/src/option/: syscall.c
software components: CMSIS:CORE 5.1.1
